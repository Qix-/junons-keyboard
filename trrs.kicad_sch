File: trrs.kicad_sch (KiCad schematic)
At the start: 6 parts, among them IC1 BD41041FJ-CE2, J2 SJ-43514-SMT-TR, J3 SJ-43514-SMT-TR

Commit message: next version
Parts:
- renumbered FB1 to FB2
